## sdkconfig.defaults
```kconfig
CONFIG_ESP32WIFIMANAGER_ENABLE_WEBSOCKET=y
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
CONFIG_ESPTOOLPY_FLASHSIZE="4MB"
```
